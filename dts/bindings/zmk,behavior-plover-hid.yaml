## dts/bindings/zmk,behavior-plover-hid.yaml
```yaml
description: Plover HID steno key press behavior

compatible: "zmk,behavior-plover-hid"

include: one_param.yaml
```
